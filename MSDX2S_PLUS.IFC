Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MSDX2S_PLUS.IFC
Time: 2026-07-29T06:59:43
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 950SA導光柱
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: C529-1鎖頭_Default_1
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: MSDX2_PLUS外殼
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: MSD_1L背板
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 圓桶型透視窗_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 多功能皂閥-泡沫出口件
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 給皂機半牙螺絲 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
